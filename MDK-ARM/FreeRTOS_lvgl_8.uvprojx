# Keil uVision project FreeRTOS_lvgl_8.uvprojx, settings and files
target FreeRTOS_lvgl_8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_lvgl_8 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,STM32F4
  c include: ../Core/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;             ../Middlewares/Third_Party/FreeRTOS/Source/include;             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;             ../Drivers/CMSIS/Include;             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;             ..\Drivers\GUI;             ..\Drivers\GUI\lvgl;             ..\Drivers\GUI\lvgl_app\lv_demos\src\lv_demo_widgets;             ..\Drivers\GUI\lvgl\examples\porting;             ..\Drivers\GUI\lvgl_app\lv_demos\src\lv_demo_music
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: bsp_lcd.c bsp_sdram.c logo_IKKEM_200.c font24.c bsp_i2c_touch.c gt9xx.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/GUI/lvgl_porting
    ../Drivers/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Drivers/GUI/lvgl_src
    ../Drivers/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Drivers/GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Drivers/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Drivers/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Drivers/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Drivers/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Drivers/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Drivers/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Drivers/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Drivers/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Drivers/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Drivers/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Drivers/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Drivers/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Drivers/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Drivers/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Drivers/GUI/lvgl/src/extra/: lv_extra.c
    ../Drivers/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Drivers/GUI/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../Drivers/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Drivers/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Drivers/GUI/lvgl_app
    ../Drivers/GUI/lvgl_app/lv_demos/src/lv_demo_widgets/: lv_demo_widgets.c
    ../Drivers/GUI/lvgl_app/lv_demos/src/lv_demo_widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
software components: CMSIS:CORE 4.3.0
